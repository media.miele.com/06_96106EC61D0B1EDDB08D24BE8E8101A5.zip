Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-07T11:49:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 07 11:49:50 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\3019eec8-1e46-473c-9b16-792acbb5a9a7\e831473b-e1f1-4ded-8e01-5d0eb72f9a53\ifc * Database version: 5507 * Database creation date: Tue Mar 07 11:49:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 07 11:49:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 07 11:49:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11502700_USA_K2802SF:36280211_USA_11502700_K2802SF, (2)
In: Default
Type - Classification: MC2000 (Uniformat); Material: z_Miele_Design_GRGR
Type - Pset_BuildingElementProxyCommon - Reference: 36280211_USA_11502700_K2802SF
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 36280211_USA_11502700_K2802SF
Type - Pset_ProvisionForVoid - Width: 756 mm; Height: 2125 mm; Depth: 608 mm
Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Zinc_Steel, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_358010
Description: Flow; FlowDirection: SOURCEANDSINK
